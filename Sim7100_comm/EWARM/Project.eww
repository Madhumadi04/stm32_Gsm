<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Sim7100_comm.ewp</path>
  </project>
  <batchBuild />
</workspace>
